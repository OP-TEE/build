COMPATIBLE_MACHINE_zynqmp = "zynqmp-generic|ultra96-zynqmp"
